# Keil uVision project Recoder_keil.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: Recoder_keil +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Recoder
  group Source Group 1
    ./: STARTUP.A51
    ./Recoder/: main.c usart.c adc.c wch372.c pcm1801.c mt8870.c timer.c
